# Keil uVision project 小球控制系统.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 小球控制系统 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\program
  group Source Group 1
    ../program/: loop.c Delay.C lcd12864.c System.c Key.C buzzer.c
